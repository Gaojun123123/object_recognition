# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\USART2;..\HARDWARE\OLED;..\HARDWARE\USART3;..\HARDWARE\DISPLAY;..\HARDWARE\GY96;..\HARDWARE\MYFUNCTION;..\HARDWARE\timer;..\HARDWARE\DISPLAY;..\HARDWARE\serial;..\HARDWARE\PID;..\HARDWARE\WAVE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAEDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/GY96/: gy96.c
    ../HARDWARE/MYFUNCTION/: myfunction.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/DISPLAY/: display.c
    ../HARDWARE/serial/: serial.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/WAVE/: wave.c
